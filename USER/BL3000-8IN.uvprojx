# Keil uVision project BL3000-8IN.uvprojx, settings and files
target 3000CD_SIM7600_foreign (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 3000SOS_SIM7600_foreign +hex
  AfterMake: D:\Development\keil\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\OBJ\3000SOS_SIM7600_foreign.bin  ..\OBJ\3000SOS_SIM7600_foreign.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_RTX_OS
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\CORE;..\HARDWARE\LED;..\HARDWARE\GSM;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\WIRE_IN;..\HARDWARE\RELAY;..\SYSTEM\wkup;..\HARDWARE\WDG;..\HARDWARE\RF433;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\USER;..\HARDWARE\Hal_ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/usart/: uart.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s RTX_Conf_CM.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_adc.c
  group Readme
    ../Readme/: Readme.txt
